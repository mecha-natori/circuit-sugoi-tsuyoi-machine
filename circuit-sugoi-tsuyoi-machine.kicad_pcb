# Repository mecha-natori/circuit-sugoi-tsuyoi-machine

File README.md:

# すごいつよいマシーン！32号

すごいつよいマシーン！32号はSTM32G474RBT6を使用した通信がメインの汎用基板です。

## 仕様

|        機能         | 個数 | 備考                                                             |
| :-----------------: | ---: | :--------------------------------------------------------------- |
|         MCU         |    1 | STM32G474RBT6                                                    |
|       ST-LINK       |    1 | ピンアサインはSWD                                                |
|         CAN         |    2 | 電源ピンは5V、CAN FD対応、2系統1つずつ                           |
|        UART         |    4 | 電源ピンは5V、LPUART1つ、USART2つ、UART1つ                       |
|         I²C         |    1 | 電源ピンは5V                                                     |
|         LED         |    4 | 簡易的なインジケータ用                                           |
|    デジタル入力     |    5 | 電源ピンは3.3V                                                   |
|    アナログ入力     |    4 | 電源ピンは3.3V                                                   |
|    外部割り込み     |    4 | 電源ピンは3.3V                                                   |
|   外部水晶発振器    |    2 | 無くても動作可能、低周波用直径2.1mm円筒状と高周波用HC49を1つずつ |
|  リセットスイッチ   |    1 |                                                                  |
| 5V-3.3Vレギュレータ |    1 | 外部電源からの供給用                                             |
|     寸法(外形)      |      | 111mm x 86mm                                                     |
|   寸法(ネジ穴間)    |      | 100mm x 75mm                                                     |

## 名前の由来

**S**ugoi **T**suyoi **M**achine **32** gouです。ただのシャレです。

## KiCad design circuit-sugoi-tsuyoi-machine.kicad_pcb

Parts:
C1, C2, C3, C4, C5: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC PN C14663
D1: LED_RED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC PN C84263
D2: LED_ORANGE; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC PN C84269
D3: LED_YELLOW; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC PN C84268
D4: LED_GREEN; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; LCSC PN C84264
R1, R2, R3, R4: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC PN C2907089
R5: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC PN C2907113
SW1: SW_MEC_5E; tact
U1: STM32G474RBTx; LQFP-64_10x10mm_P0.5mm; LCSC PN C529413

Connections:
+3.3V: C1.1, C2.1, C3.1, C4.1, C5.1, R5.1, U1.1 (VBAT), U1.16 (VDD), U1.28 (VREF+), U1.29 (VDDA), U1.32 (VDD), U1.48 (VDD), U1.64 (VDD); also elsewhere on the board
AIN1: U1.12 (PA0); also elsewhere on the board
AIN2: U1.13 (PA1); also elsewhere on the board
AIN3: U1.14 (PA2); also elsewhere on the board
AIN4: U1.17 (PA3); also elsewhere on the board
DIN1: U1.22 (PC4); also elsewhere on the board
DIN2: U1.23 (PC5); also elsewhere on the board
DIN3: U1.24 (PB0); also elsewhere on the board
DIN4: U1.25 (PB1); also elsewhere on the board
DIN5: U1.26 (PB2); also elsewhere on the board
EXTI10: U1.30 (PB10); also elsewhere on the board
EXTI11: U1.33 (PB11); also elsewhere on the board
EXTI14: U1.36 (PB14); also elsewhere on the board
EXTI15: U1.37 (PB15); also elsewhere on the board
FDCAN1_RX: U1.45 (PA11); also elsewhere on the board
FDCAN1_TX: U1.46 (PA12); also elsewhere on the board
FDCAN2_RX: U1.34 (PB12); also elsewhere on the board
FDCAN2_TX: U1.35 (PB13); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), SW1.1, SW1.2, U1.15 (VSS), U1.27 (VSSA), U1.31 (VSS), U1.47 (VSS), U1.63 (VSS); also elsewhere on the board
HSE_IN: U1.5 (PF0); also elsewhere on the board
HSE_OUT: U1.6 (PF1); also elsewhere on the board
I2C1_SCL: U1.61 (PB8); also elsewhere on the board
I2C1_SDA: U1.60 (PB7); also elsewhere on the board
LPUART1_RX: U1.8 (PC0); also elsewhere on the board
LPUART1_TX: U1.9 (PC1); also elsewhere on the board
LSE_IN: U1.3 (PC14); also elsewhere on the board
LSE_OUT: U1.4 (PC15); also elsewhere on the board
NRST: R5.2, SW1.3 (K), SW1.4 (A), U1.7 (PG10); also elsewhere on the board
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: R1.1, U1.18 (PA4)
unnamed: R2.1, U1.19 (PA5)
unnamed: R3.1, U1.20 (PA6)
unnamed: R4.1, U1.21 (PA7)
SWCLK: U1.50 (PA14); also elsewhere on the board
SWDIO: U1.49 (PA13); also elsewhere on the board
SWO: U1.56 (PB3); also elsewhere on the board
UART5_RX: U1.55 (PD2); also elsewhere on the board
UART5_TX: U1.54 (PC12); also elsewhere on the board
USART1_RX: U1.44 (PA10); also elsewhere on the board
USART1_TX: U1.43 (PA9); also elsewhere on the board
USART3_RX: U1.53 (PC11); also elsewhere on the board
USART3_TX: U1.52 (PC10); also elsewhere on the board

Parts:
C6, C7, C8, C9, C10, C11: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; LCSC PN C14663
U2: AP130-33Y; SOT-89-3; LCSC PN C236803
U3: ATA6561-GAQW; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.71x3.4mm; LCSC PN C2929602
U4: TJA1441AT; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.71x3.4mm; LCSC PN C3234084
Y1: HSE; Crystal_HC49-U_Vertical
Y2: LSE; Crystal_C26-LF_D2.1mm_L6.5mm_Vertical

Connections:
+3.3V: C7.1, C9.1, C11.1, U2.1 (VO), U3.5 (VIO), U4.5 (VIO); also elsewhere on the board
+5V: C6.1, C8.1, C10.1, U2.3 (VI), U3.3 (VCC), U4.3 (VCC); also elsewhere on the board
CAN1_N: U3.6 (CANL); also elsewhere on the board
CAN1_P: U3.7 (CANH); also elsewhere on the board
CAN2_N: U4.6 (CANL); also elsewhere on the board
CAN2_P: U4.7 (CANH); also elsewhere on the board
FDCAN1_RX: U3.4 (RXD); also elsewhere on the board
FDCAN1_TX: U3.1 (TXD); also elsewhere on the board
FDCAN2_RX: U4.4 (RXD); also elsewhere on the board
FDCAN2_TX: U4.1 (TXD); also elsewhere on the board
GND: C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, U2.2 (GND), U3.2 (GND), U3.8 (S), U3.9 (GND), U4.2 (GND), U4.8 (S), U4.9 (GND); also elsewhere on the board
HSE_IN: Y1.2; also elsewhere on the board
HSE_OUT: Y1.1; also elsewhere on the board
LSE_IN: Y2.2; also elsewhere on the board
LSE_OUT: Y2.1; also elsewhere on the board

Parts:
J1: PWR; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J2: ST-LINK; JST_ZH_B6B-ZR_1x06_P1.50mm_Vertical
J3: UART1; DF1B-4P-2.5DSA
J4: UART2; DF1B-4P-2.5DSA
J5: UART3; DF1B-4P-2.5DSA
J6: UART4; DF1B-4P-2.5DSA
J7: I2C; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J8: CAN1; JST_XA_B04B-XASK-1_1x04_P2.50mm_Vertical
J9: CAN2; JST_XA_B04B-XASK-1_1x04_P2.50mm_Vertical
J10: DIN1; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J11: DIN2; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J12: DIN3; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J13: DIN4; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J14: DIN5; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J15: AIN1; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J16: AIN2; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J17: AIN3; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J18: AIN4; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J19: EXTI1; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J20: EXTI2; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J21: EXTI3; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical
J22: EXTI4; JST_XA_B03B-XASK-1_1x03_P2.50mm_Vertical

Connections:
+3.3V: J2.1, J10.1 (+3.3V), J11.1 (+3.3V), J12.1 (+3.3V), J13.1 (+3.3V), J14.1 (+3.3V), J15.1 (+3.3V), J16.1 (+3.3V), J17.1 (+3.3V), J18.1 (+3.3V), J19.1 (+3.3V), J20.1 (+3.3V), J21.1 (+3.3V), J22.1 (+3.3V); also elsewhere on the board
+5V: J1.2 (+5V), J3.1 (+5V), J4.1 (+5V), J5.1 (+5V), J6.1 (+5V), J7.1 (+5V), J8.1 (+5V), J9.1 (+5V); also elsewhere on the board
AIN1: J15.2 (SIG); also elsewhere on the board
AIN2: J16.2 (SIG); also elsewhere on the board
AIN3: J17.2 (SIG); also elsewhere on the board
AIN4: J18.2 (SIG); also elsewhere on the board
CAN1_N: J8.3 (CAN_N); also elsewhere on the board
CAN1_P: J8.2 (CAN_P); also elsewhere on the board
CAN2_N: J9.3 (CAN_N); also elsewhere on the board
CAN2_P: J9.2 (CAN_P); also elsewhere on the board
DIN1: J10.2 (SIG); also elsewhere on the board
DIN2: J11.2 (SIG); also elsewhere on the board
DIN3: J12.2 (SIG); also elsewhere on the board
DIN4: J13.2 (SIG); also elsewhere on the board
DIN5: J14.2 (SIG); also elsewhere on the board
EXTI10: J19.2 (SIG); also elsewhere on the board
EXTI11: J20.2 (SIG); also elsewhere on the board
EXTI14: J21.2 (SIG); also elsewhere on the board
EXTI15: J22.2 (SIG); also elsewhere on the board
GND: J1.3 (GND), J2.3, J3.2 (GND), J4.2 (GND), J5.2 (GND), J6.2 (GND), J7.2 (GND), J8.4 (GND), J9.4 (GND), J10.3 (GND), J11.3 (GND), J12.3 (GND), J13.3 (GND), J14.3 (GND), J15.3 (GND), J16.3 (GND), J17.3 (GND), J18.3 (GND), J19.3 (GND), J20.3 (GND), J21.3 (GND), J22.3 (GND); also elsewhere on the board
I2C1_SCL: J7.4 (SCL); also elsewhere on the board
I2C1_SDA: J7.3 (SDA); also elsewhere on the board
LPUART1_RX: J3.4 (RX); also elsewhere on the board
LPUART1_TX: J3.3 (TX); also elsewhere on the board
NRST: J2.5; also elsewhere on the board
SWCLK: J2.2; also elsewhere on the board
SWDIO: J2.4; also elsewhere on the board
SWO: J2.6; also elsewhere on the board
UART5_RX: J6.4 (RX); also elsewhere on the board
UART5_TX: J6.3 (TX); also elsewhere on the board
USART1_RX: J4.4 (RX); also elsewhere on the board
USART1_TX: J4.3 (TX); also elsewhere on the board
USART3_RX: J5.4 (RX); also elsewhere on the board
USART3_TX: J5.3 (TX); also elsewhere on the board

Board: 2 copper layers, 111.0 x 86.0 mm, 53 parts (0 on the bottom side), 50 nets.

Other parts of the board:
 : holeφ3.2
 #2,  #3,  #4: holeφ3.2

## Commit log

2025-03-31 doc: READMEとMITライセンスを追加。
2025-04-01 doc: 寸法を追記。
2025-04-01 chore: JLCPCBのPCBA発注用設定・ツールを追加。
2025-04-01 fix: ロゴに不要な表記が混ざっている。
2025-04-01 chore: 圧縮ガーバー作成タスクを追加。
2025-04-01 feature: MCUをSTM32G473RBT6からSTM32G474RBT6へ変更。
2025-04-01 feature: CANトランシーバーをTJA1441ATからATA6561-GAQWへ変更。
2025-04-01 feature: GNDのベタ塗りを調整。
2025-04-04 chore: Makefileを可搬性のあるものへ置き換え。
